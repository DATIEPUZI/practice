# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60F15
  ICCARM.CCIncludePath2: ..\..\Libraries\startup\CoreSupport; ..\..\Libraries\startup\DeviceSupport; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drvier
    ./: interrupt.c interrupt.h
  group startup
    ../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../Libraries/startup/DeviceSupport/: system_MK60F15.c
  group user
    ./: main.c
